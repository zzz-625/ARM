# Keil uVision project ARM.uvproj, settings and files
target ARM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M032TD2AE Nuvoton
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0xFFFF) CLOCK(48000000) CPUTYPE("Cortex-M0")
  output: ARM
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1
  c include: ..\Library\nuvoton\CMSIS\Include;..\Library\nuvoton\Device\Nuvoton\M031\Include;..\Library\nuvoton\StdDriver\inc;..\Library\fih\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --map --first='startup_M031Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../Library/nuvoton/Device/Nuvoton/M031/Source/: system_M031Series.c
    ../Library/nuvoton/Device/Nuvoton/M031/Source/ARM/: startup_M031Series.s
  group Library
    ../Library/nuvoton/StdDriver/src/: retarget.c uart.c clk.c gpio.c sys.c wdt.c fmc.c usbd.c spi.c
    ../Library/fih/src/: lontium_i2c.c dlpc3433_i2c.c mcu_i2c.c lt7911_upgrade.c spi_wwitch_tc7mbl3257cfk.c download_flag.c mcu_version.c calibration.c descriptors.c hid_transfer.c
  group User
    ../: main.c
